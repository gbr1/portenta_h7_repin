# Repository gbr1/portenta_h7_repin

File README.md:

# Portenta H7 *Repin*

A simple board to use Portenta without soldering pin headers.

 <br>
 <br>
 <br>

It also exposes SWD ST-Link pins in the same order of Nucleo-64 boards, so you can use to debug.
<br>

<br>

### BOM:

you only need 2 DF40HC(3.5)-80DS-0.4V(51) and 2 1x14 pins headers.
<br>
<br>

***This project is under GPL v3.0 license.<br>
Copyright 2021 © Giovanni di Dio Bruno - [gbr1.github.io](gbr1.github.io) - giovannididio.bruno@gmail.com***

## EAGLE design eagle/portenta_h7_repin.brd

Parts:
J1, J2: HIROSE_DF40C-80DS-0.4V_51HIROSE_DF40C-80DS-0.4V_5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; HIROSE_DF40C-80DS-0.4V_51_0
JP1, JP2: PINHD-1X14; 1X14
JP3: PINHD-1X5; 1X05

Connections:
3V3: J1.76, J2.24, J2.46, J2.59, J2.69, JP1.3
5V: J1.12, JP1.1
AREF: J2.45, JP2.1
GND: J1.16, J1.24, J1.51, J1.61, J1.67, J2.6, J2.19, J2.29, J2.52, J2.64, JP1.4, JP3.2
J1-33: J1.17, JP1.6
J1-35: J1.18, JP1.7
J1-44: J1.62, JP1.9
J1-46: J1.63, JP1.8
J2-36: J2.23, JP1.13
J2-38: J2.22, JP1.11
J2-40: J2.21, JP1.10
J2-42: J2.20, JP1.12
J2-59: J2.51, JP1.14
J2-60: J2.11, JP2.10
J2-61: J2.50, JP2.14
J2-62: J2.10, JP2.9
J2-63: J2.49, JP2.13
J2-65: J2.48, JP2.12
J2-67: J2.47, JP2.11
J2-73: J2.44, JP2.2
J2-74: J2.4, JP2.6
J2-75: J2.43, JP2.3
J2-76: J2.3, JP2.7
J2-77: J2.42, JP2.4
J2-78: J2.2, JP2.8
J2-79: J2.41, JP2.5
NRST: J1.37, JP1.5, JP3.4
SWCLK: J1.39, JP3.1
SWDIO: J1.38, JP3.3
SWO: J1.40, JP3.5
VIN: J1.11, J1.21, J1.56, J1.64, JP1.2

Notes on the sheet:
top left
top right
Giovanni di Dio Bruno gbr1.github.io giovannididio.bruno@gmail.com
v1.1
GPL v3.0

Board: 2 copper layers, 66.0 x 25.4 mm, 5 parts (1 on the bottom side), 31 nets.

## Commit log

2021-03-31 added files
2022-01-17 added 3d model
2022-03-31 fix serial1
2022-03-31 readme
